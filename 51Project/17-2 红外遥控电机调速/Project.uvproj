# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h Key.c Key.h LCD1602.c LCD1602.h I2C.c I2C.h AT24C02.c AT24C02.h Nixie.c Nixie.h DS18820.c DS18820.h Buzzer.c Buzzer.h OneWire.c OneWire.h Int0.c Int0.h Timer1.c Timer1.h Timer0.c Timer0.h Motor.c Motor.h IR.c IR.h
