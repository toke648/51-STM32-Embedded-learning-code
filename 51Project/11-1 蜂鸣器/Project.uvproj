# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h LCD1602.c LCD1602.h MatrixKey.c MatrixKey.h Timer0.c Timer0.h DS1302.c DS1302.h Nixie.c Nixie.h Key.c Key.h Buzzer.c Buzzer.h
